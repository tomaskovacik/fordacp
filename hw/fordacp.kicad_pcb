# Repository tomaskovacik/fordacp

File README.md:

SW is Dale Thomas/Krzysztof Pintscher/Andrew Hammond work not my

www.instructables.com/id/Ford-CD-Emulator-Arduino-Mega/
http://www.instructables.com/id/Ford-Bluetooth-Interface-Control-phone-with-stock-/

I make just HW part in kicad, libraries for BLK-MD-SPK-B and S3860M-S <a href="https://github.com/tomaskovacik/hw/tree/master/kicad/library">here</a>

work in progress

untested

<a href="http://kovo-blog.blogspot.sk/2015/01/breadboard-adapter-for-blk-md-spk-b.html">BLK-MD-SPK-B</a> module support.
<a href="http://kovo-blog.blogspot.sk/2015/06/xs3868-breadbord-adapter.html">S3860M-S</a> module support.

schematics
------------
<a href="https://github.com/tomaskovacik/fordacp/raw/master/hw/schematics.pdf">schematics in pdf</a>

3d render
---------

with LCD

without LCD

## KiCad design hw/fordacp.kicad_pcb

Parts:
C1: 47u/25V; TantalC_SizeD_EIA-7343_HandSoldering
C2, C5, C6, C7, C8, C9: 100n/50V; C_0805_HandSoldering
C3: 1uf/10V; C_0805_HandSoldering
C4: 4u7/10V; C_1206_HandSoldering
C10, C11: 1u/16V; C_0805_HandSoldering
C12, C13: 22; C_0805
D1: GREEN; LED-1206
D2: RED; LED-1206
D3: 5V1; MiniMELF_Standard
DS1: LCD-016N002L; WC1602A
IC1: ATMEGA2560-A; TQFP-100_14x14mm_Pitch0.5mm
L1: 15nH; SMD-1206_Pol
MIC1: CONN_01X02; Pin_Header_Straight_1x02
P1: CONN_02X06; Pin_Header_Straight_2x06
P2: CONN_02X03; Pin_Header_Straight_2x03
R1: 2k7(3k3); R_0805_HandSoldering
R2: 1M; R_0805_HandSoldering
R3: 27R; R_0805_HandSoldering
R4, R5: 470; R_0805_HandSoldering
R6: 6k8; R_0805_HandSoldering
R7: 4k7; R_0805_HandSoldering
R8, R9: 10k; R_0805_HandSoldering
RV1: 1k; Potentiometer_Bourns_3339H_Angular_ScrewUp
U1: SP3485CN; SO-8
U2: AP1117D50; SOT-223-REGULATOR
U3: BLK-MD-SPK-B
U4: XS3868
Y1: 16MHz; Q_49U3HMS
programing1: CONN_01X05; Pin_Header_Straight_1x05

Connections:
+5V: C5.1, C6.1, C7.1, C8.1, DS1.2 (VDD), DS1.15 (LED+), IC1.10 (VCC), IC1.31 (VCC), IC1.80 (VCC), IC1.100 (AVCC), P2.2, R4.1, R5.1, R8.2, R9.2, RV1.1, U1.8 (VCC), U2.VO, U3.12 (VBAT), U4.12, programing1.4
+12V: C1.1, C2.1, P1.6, U2.VI
/ARD_AREF: C9.1, IC1.98 (AREF)
/ARD_RESET: C10.1, IC1.30 (~RESET), P2.5, R8.1, programing1.1
/AUXINL: P1.9, U3.4 (SPKLP), U4.3
/AUXINR: P1.11, U3.5 (SPKRP), U4.4
/BT_RST: C11.1, R9.1, U3.18 (RST), U4.17
/BT_RX: IC1.13 (PH1(TXD2)), U3.20 (RXD), U4.21
/BT_TX: IC1.12 (PH0(RXD2)), U3.19 (TXD), U4.20
/BT_WAKE: IC1.17 (PH5(OC4C)), U3.15 (MFB), U4.19
/ENABLE: P1.4, R6.2
/ENABLE_5V: D3.1 (K), IC1.71 ((AD7)PA7), R6.1, R7.2
/LCD_D4: DS1.11 (D4), IC1.18 (PH6(OC2B))
/LCD_D5: DS1.12 (D5), IC1.23 ((PCINT4/OC2A)PB4)
/LCD_D6: DS1.13 (D6), IC1.24 ((PCINT5/OC1A)PB5)
/LCD_D7: DS1.14 (D7), IC1.25 ((PCINT6/OC1B)PB6)
/LCD_E: DS1.6 (E), IC1.1 (PG5(OCOB))
/LCD_RS: DS1.4 (RS), IC1.4 ((XCK0/AIN0)PE2)
/LCD_RW: DS1.5 (R/W), IC1.7 ((OC3C/INT5)PE5)
/LED1: D1.1 (K), U3.9 (BLED), U4.7
/LED2: D2.1 (K), U3.11 (RLED), U4.8
/MIC: C3.2, U3.7 (MIC), U4.5
/MIC_BIAS: C4.1, L1.1, U3.8 (VMIC), U4.6
/MISO: IC1.22 ((PCINT3/MISO)PB3), P2.1
/MOSI: IC1.21 ((PCINT2/MOSI)PB2), P2.4
/RS485-A: P1.1, U1.6 (A)
/RS485-B: P1.2, U1.7 (B)
/RS485_DI: IC1.46 ((TXD1/INT3)PD3), U1.4 (DI)
/RS485_ENA: IC1.72 ((AD6)PA6), U1.2 (~RE~), U1.3 (DE)
/RS485_R0: IC1.45 ((RXD1/INT2)PD2), U1.1 (RO)
/RX0: IC1.2 ((PCINT8/RXD0)PE0), programing1.2
/SCK: IC1.20 ((PCINT1/SCK)PB1), P2.3
/TX0: IC1.3 ((TXD0)PE1), programing1.3
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D3.2 (A), DS1.1 (VSS), DS1.16 (LED-), IC1.11 (GND), IC1.32 (GND), IC1.81 (GND), IC1.99 (GND), MIC1.2, P1.5, P2.6, R7.1, RV1.3, U1.5 (GND), U2.GND, U3.1 (GND), U3.2 (GND), U3.13 (GND), U3.25 (GND), U3.26 (GND), U4.11, programing1.5
GNDA: P1.10, P1.12, U3.3 (SPKN), U4.2
unnamed: C3.1, MIC1.1, R1.1
unnamed: C12.1, IC1.33 (XTAL2), R2.1, Y1.1
unnamed: C13.1, R2.2, R3.2, Y1.2
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: DS1.3 (VO), RV1.2
unnamed: IC1.34 (XTAL1), R3.1
unnamed: L1.2, R1.2

Board: 2 copper layers, 39.7 x 28.7 mm, 36 parts (28 on the bottom side), 35 nets.

## Commit log

2015-10-14 readme init
2015-10-14 SW part of fordacp from Dale Thomas
2015-10-14 HW schematics
2015-10-14 pcb first try
2015-10-14 3d render
2015-10-14 schematics
2015-10-14 rename hw/fordacp.pdf hw/schematics.pdf
2015-10-15 .gitignore
2015-10-15 schematics export to png
2015-10-15 readme update - schematics
2015-10-15 readme update
2015-10-15 pcb without LCD
2015-10-15 .gitignore changes
2015-10-15 change modules to 1206 for 1u 2u2 4u7 capacitors
2015-10-15 rename to _3d.png
2015-10-15 update pcb without LCD
2015-11-20 added SPI interface
2015-11-20 add SPI schematics file
2015-11-20 add SPI schematics file in pdf
2015-11-20 schematics cleanup
2015-11-23 typo
2015-12-10 pictures of assembled unit
2015-12-10 L1 better housing
2016-01-05 rename xs3860 to xs3868
2016-01-05 set PCB witout LCD as default
2016-01-05 renam XS3860 to XS3868
2016-01-07 rename XS3868 to S3860M-S
2016-01-08 url fix to S3860M-S blog post
2016-01-11 differential output amplifier with LM358
2017-02-22 mentioned all autors in readme
2017-02-22 links to instructables
2018-06-05 latest modification, I do not remember what it is ...
